# Keil uVision project Fire_H743.uvprojx, settings and files
target Fire_H7_InFlash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H743XIHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Fire_emxgui
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,X_GUI_USE_FREERTOS,APPLICATION_ADDRESS=0x8000000,Fire_H7_InFlash,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F7,NDEBUG,
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User;..\..\User\bsp;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM7\r0p1;..\..\User\bsp\cm_backtrace;..\..\emXGUI_Lib\inc;..\..\emXGUI_Lib\drv;..\..\emXGUI_Lib\arch\Inc;..\..\emXGUI_Lib\app\base;..\..\User\bsp\FATFS;..\..\emXGUI_Lib\app\base\res_writer;..\..\emXGUI_Lib\app\tutorial\rgb_led;..\..\User\OwnerDraw;..\..\emXGUI_Lib\app\tutorial\music_player;..\..\User\bsp\mp3\real;..\..\User\bsp\mp3\pub;..\..\emXGUI_Lib\app\tutorial\pic_view;..\..\emXGUI_Lib\app\tutorial\camera;..\..\emXGUI_Lib\app\base\boot_interface;..\..\User\bsp\app\Board_App;..\..\User\bsp\app\Board_App;..\..\User\bsp\app\Board_App\gyro\mpu6050\driver\include;..\..\User\bsp\app\Board_App\gyro\mpu6050\mllite;..\..\User\bsp\app\Board_App\gyro\i2c;..\..\User\bsp\app\Board_App\gyro\mpu6050\driver\eMPL;..\..\User\bsp\app\Board_App\gyro\mpu6050\mpl;..\..\User\bsp\app\Board_App\gyro\mpu6050\eMPL-hal;..\..\User\bsp\app\Board_App\gyro\mpu6050\driver\stm32L;..\..\User\bsp\app\Board_App\gyro\mpu6050;..\..\User\bsp\app\GUI_Demo;..\..\User\bsp\app\Board_App\NetworkDLG\lwipapp;..\..\User\bsp\app\Board_App\NetworkDLG\bsp\;..\..\User\bsp\app\Board_App\NetworkDLG\bsp\LAN8720A;..\..\User\bsp\app\Board_App\gyro\mpu6050;..\..\User\bsp\app\Board_App\NetworkDLG\LwIP\include\lwip;..\..\User\bsp\app\Board_App\NetworkDLG\LwIP\include;..\..\User\bsp\app\Board_App\NetworkDLG;..\..\User\bsp\app\Board_App\NetworkDLG\arch;..\..\emXGUI_Lib\;..\..\User\bsp\app\Board_App\camera;..\..\User\bsp\app\Board_App\camera\QR_Decoder
  asm define: __EVAL
  memory RVCT4: ROM 0x8000000 size 0x2000000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\..\Output\Fire_emxgui .sct
  group STARTUP
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h750xx.s
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group STM32H7xx_HAL_Driver
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_usart_ex.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c
  group USER
    ../../User/: main.c stm32h7xx_it.c board.h FreeRTOSConfig.h cpuusage.c
  group BSP
    ../../User/bsp/led/: bsp_led.c
    ../../User/bsp/usart/: bsp_usart.c
    ../../User/bsp/sdram/: bsp_sdram.c
    ../../User/bsp/flash/: bsp_qspi_flash.c
    ../../User/bsp/lcd/: bsp_lcd.c
    ../../User/bsp/delay/: core_delay.c
    ../../User/bsp/touch/: bsp_i2c_touch.c bsp_touch_gtxx.c
    ../../User/bsp/sd_card/: bsp_sdio_sd.c
    ../../User/bsp/tim/: bsp_basic_tim.c
    ../../User/bsp/dma2d/: dma2d_emxgui.c
    ../../User/bsp/wm8978/: bsp_wm8978.c
    ../../User/bsp/i2c/: i2c.c
    ../../User/bsp/sai/: bsp_sai.c
    ../../User/bsp/mpu/: bsp_mpu.c
    ../../User/bsp/beep/: bsp_beep.c
    ../../User/bsp/key/: bsp_key.c
  group Fafts
    ../../User/bsp/FATFS/: diskio.c ff.c ffconf.h ff_gen_drv.c
    ../../User/bsp/FATFS/option/: cc936.c syscall.c
    ../../User/bsp/FATFS/drivers/: sd_diskio_dma.c fatfs_sd_sdio.c
  group FreeRTOS/src
    ../../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../../FreeRTOS/port/MemMang/: heap_4.c
    ../../FreeRTOS/port/RVDS/ARM_CM7/r0p1/: port.c
  group cm_backtrace
    ../../User/bsp/cm_backtrace/: cm_backtrace.c cm_backtrace.h cmb_cfg.h cmb_def.h
    ../../User/bsp/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group emxgui/arch
    ../../emXGUI_Lib/arch/: GUI_Arch.c GUI_GPU.c
    ../../emXGUI_Lib/arch/OS_Options/: X_GUI_FreeRTOS.c
    ../../emXGUI_Lib/arch/Inc/: gui_drv.h gui_os_port.h
  group emxgui/resource
    ../../emXGUI_Lib/resource/xft_font/: ASCII_16_4BPP.c ASCII_20_4BPP.c ASCII_24_4BPP.c GB2312_16_2BPP.c
  group emxgui/inc
    ../../emXGUI_Lib/inc/: def.h emXGUI.h emXGUI_Arch.h GUI_Font_XFT.h Web_Color.h x_libc.h x_obj.h Clist.h
  group emxgui/libs
    ../../emXGUI_Lib/libs/: emXGUI100_MDK_M7.lib libjpeg_MDK_M7.lib libpng_MDK_M7.lib x_obj.cpp x_libc_MDK_M7.lib libjpeg_MDK_M4.lib emXGUI100_MDK_M4.lib
  group emxgui/drv
    ../../User/: gui_drv_cfg.h
    ../../emXGUI_Lib/drv/: gui_font_port.c gui_fs_port.c gui_input_port.c gui_lcd_port.c gui_log_port.c gui_mem_port.c gui_resource_port.c gui_touch_port.c gui_picture_port.c
  group emxgui/res
    ../../emXGUI_Lib/app/base/boot_interface/: boot_logo.c
  group OEM_Face
    ../../emXGUI_Lib/OEM_Face/: OEM_Button.c OEM_CheckBox.c OEM_GroupBox.c OEM_ListBox.c OEM_ProgressBar.c OEM_RadioBox.c OEM_ScrollBar.c OEM_TextBox.c
  group boot_window
    ../../emXGUI_Lib/app/base/boot_interface/pic_load/: gui_pic_load.c
    ../../emXGUI_Lib/drv/: gui_startup.c
    ../../emXGUI_Lib/app/base/: gui_desktop.c GUI_AppDef.h
    ../../emXGUI_Lib/app/base/boot_interface/: GUI_Boot_Interface_Dialog.c
    ../../User/bsp/app/Board_App/: GUI_Board_App_Desktop.c
    ../../User/bsp/app/GUI_Demo/: GUI_DEMO_SlideWindow.c
  group base_app
    ../../emXGUI_Lib/app/base/res_writer/: backend_res_writer.c GUI_RES_Writer_Dialog.c
  group APP_GUI
    ../../User/bsp/app/GUI_Demo/: CListMenu.cpp GUI_App_Desktop.c GUI_DEMO_Graphics_Accelerator.c GUI_DEMO_ShowWave.cpp calculator.cpp GUI_DEMO_AutoMeter.c GUI_DEMO_Number_Keyboard.c GUI_SelectDialogBox.c GUI_DEMO_Button_OwnerDraw.c GUI_DEMO_Button.c GUI_DEMO_Checkbox.c GUI_DEMO_Listbox.c GUI_DEMO_Messagebox.c GUI_DEMO_Progressbar.c GUI_DEMO_RadiaMenu.c GUI_DEMO_Radiobox.c GUI_DEMO_Scrollbar.c GUI_DEMO_Scrollbar_OwnerDraw.c GUI_DEMO_Textbox.c number_input.c
    ../../User/OwnerDraw/: Widget.c
  group tutorial/mp3
    ../../User/bsp/app/Board_App/mp3_player/: GUI_MUSICPLAYER_DIALOG.c GUI_MusicList_DIALOG.c Backend_mp3Player.c
  group tutorial/bsp_mp3
    ../../User/bsp/app/Board_App/mp3_decoder/: mp3dec.c mp3tabs.c
    ../../User/bsp/app/Board_App/mp3_decoder/real/: assembly.h bitstream.c buffers.c coder.h dct32.c dequant.c dqchan.c huffman.c hufftabs.c imdct.c scalfact.c stproc.c subband.c trigtabs.c
    ../../User/bsp/app/Board_App/mp3_decoder/real/arm/: asmmisc.s asmpoly_thumb2.s
    ../../User/bsp/app/Board_App/mp3_decoder/pub/: mp3common.h mp3dec.h mpadecobjfixpt.h statname.h
  group tutorial/recorder
    ../../User/bsp/app/Board_App/recorder/: Backend_Recorder.c GUI_RECORDER_DIALOG.c
  group tutorial/rgb_led
    ../../User/bsp/app/Board_App/rgb_led/: Backend_RGBLED.c GUI_RGBLED_DIALOG.c
  group tutorial/pic_viwer
    ../../User/bsp/app/Board_App/pic_viewer/: GUI_PicViewr_Dialog.c GUI_PicViewr_Dialog.h
  group tutorial/video_player
    ../../User/bsp/app/Board_App/video_player/: Backend_avifile.c Backend_avifile.h Backend_vidoplayer.c Backend_vidoplayer.h GUI_VEDIOPLAYER_DIALOG.c GUI_VEDIOPLAYER_DIALOG.h
  group tutorial/PhoneCallMonitorTask
    ../../User/bsp/app/Board_App/Phone_SMS/: GUI_Phone_Dialog.c GUI_SMS_Dialog.c
    ../../User/bsp/app/Board_App/Phone_SMS/bsp_sim/: bsp_gsm_gprs.c bsp_gsm_gprs.h bsp_gsm_usart.c bsp_gsm_usart.h
  group tutorial/camera
    ../../User/bsp/app/Board_App/camera/: bsp_ov5640.c GUI_Camera_Dialog.c GUI_Camera_QRCode_Dialog.c ov5640_AF.c
    ../../User/bsp/app/Board_App/camera/QR_Decoder/: QR_Core.lib
  group tutorial/dth11
    ../../User/bsp/app/Board_App/T_RH/: GUI_T_RH_Dialog.c
    ../../User/bsp/app/Board_App/T_RH/DHT11/: bsp_dht11.c
  group tutorial/adc
    ../../User/bsp/app/Board_App/adc_Collect_voltage/: bsp_adc.c bsp_adc.h GUI_ADC_CollectVoltage_Dialog.c GUI_ADC_CollectVoltage_Dialog.h
  group tutorial/clock
    ../../User/bsp/app/Board_App/clock/: GUI_CLOCK_DIALOG.c
    ../../User/bsp/app/Board_App/clock/RTC/: bsp_rtc.c
  group tutorial/gyro
    ../../User/bsp/app/Board_App/gyro/: GUI_Gyro_Dialog.c
    ../../User/bsp/app/Board_App/gyro/mpu6050/: bsp_mpu_exti.c
  group tutorial/setting
    ../../User/bsp/app/Board_App/setting/: GUI_DEMO_Settings.c
  group tutorial/lwip
    ../../User/bsp/app/Board_App/NetworkDLG/: GUI_Network_Dialog.c
    ../../User/bsp/app/Board_App/NetworkDLG/bsp/eth/: bsp_eth.c
    ../../User/bsp/app/Board_App/NetworkDLG/bsp/LAN8720A/: LAN8720a.c
  group tutorial/beep
    ../../User/bsp/app/Board_App/beeper_control/: GUI_Beeper_Dialog.c
  group tutorial/LED&KEY
    ../../User/bsp/app/Board_App/LED_Key/: GUI_LED_KEY_Dialog.c
  group MPU_eMPL
    ../../User/bsp/app/Board_App/gyro/mpu6050/eMPL-hal/: eMPL_outputs.c
    ../../User/bsp/app/Board_App/gyro/mpu6050/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../User/bsp/app/Board_App/gyro/mpu6050/driver/stm32L/: log_stm32.c
  group MPU_mllite
    ../../User/bsp/app/Board_App/gyro/mpu6050/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
  group MPU_mpl
    ../../User/bsp/app/Board_App/gyro/mpu6050/mpl/libmpllib_Keil_M4/: libmpllib.lib
  group LwIP/api
    ../../User/bsp/app/Board_App/NetworkDLG/LwIP/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/core
    ../../User/bsp/app/Board_App/NetworkDLG/LwIP/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../User/bsp/app/Board_App/NetworkDLG/LwIP/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LwIP/netif
    ../../User/bsp/app/Board_App/NetworkDLG/LwIP/netif/: ethernet.c lowpan6.c lowpan6_ble.c lowpan6_common.c bridgeif.c zepif.c
  group LwIP/arch
    ../../User/bsp/app/Board_App/NetworkDLG/arch/: sys_arch.c ethernetif.c lwipopts.h
    ../../User/bsp/app/Board_App/NetworkDLG/LwIP/include/lwip/: opt.h
  group LwIP/app
    ../../User/bsp/app/Board_App/NetworkDLG/lwipapp/: tcp_echoclient.c tcp_echoserver.c tcpecho.c udp_echoclient.c udp_echoserver.c
  group DOC
    ../../: 必读说明.txt
  group JPEG_SingleBuffer
    ../../User/: Jepg.c Jepg.h
target Fire_emxgui (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32H750XBHx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.3.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Fire_emxgui
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H750xx,X_GUI_USE_FREERTOS,APPLICATION_ADDRESS=0x90000000,Fire_H7_InFlash,USE_DMP,MPL_LOG_NDEBUG=1,EMPL,MPU6050,EMPL_TARGET_STM32F7,NDEBUG,
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User;..\..\User\bsp;..\..\FreeRTOS\include;..\..\FreeRTOS\port\RVDS\ARM_CM7\r0p1;..\..\User\bsp\cm_backtrace;..\..\emXGUI_Lib\inc;..\..\emXGUI_Lib\drv;..\..\emXGUI_Lib\arch\Inc;..\..\emXGUI_Lib\app\base;..\..\User\bsp\FATFS;..\..\emXGUI_Lib\app\base\res_writer;..\..\emXGUI_Lib\app\tutorial\rgb_led;..\..\User\OwnerDraw;..\..\emXGUI_Lib\app\tutorial\music_player;..\..\User\bsp\mp3\real;..\..\User\bsp\mp3\pub;..\..\emXGUI_Lib\app\tutorial\pic_view;..\..\emXGUI_Lib\app\tutorial\camera;..\..\emXGUI_Lib\app\base\boot_interface;..\..\User\bsp\app\Board_App;..\..\User\bsp\app\Board_App\NetworkDLG\lwipapp;..\..\User\bsp\app\Board_App\NetworkDLG\LwIP;..\..\User\bsp\app\Board_App\NetworkDLG\arch;..\..\User\bsp\app\Board_App\NetworkDLG\LwIP\include;..\..\User\bsp\app\Board_App\NetworkDLG\arch;..\..\User\bsp\app\Board_App\NetworkDLG\bsp\LAN8720A;..\..\User\bsp\app\Board_App\NetworkDLG\bsp;..\..\User\bsp\app\Board_App\NetworkDLG;..\..\User\bsp\app\Board_App\gyro\mpu6050\driver\eMPL;..\..\User\bsp\app\Board_App\gyro\mpu6050\driver\include;..\..\User\bsp\app\GUI_Demo;..\..\User\bsp\app\Board_App\NetworkDLG\LwIP\include\lwip;..\..\User\bsp\app\Board_App\gyro\mpu6050\mllite;..\..\User\bsp\app\Board_App\gyro\mpu6050;..\..\User\bsp\app\Board_App\gyro\mpu6050\mpl;..\..\User\bsp\app\Board_App\gyro\mpu6050\eMPL-hal;..\..\User\bsp\app\Board_App\gyro\mpu6050\driver\stm32L;..\..\User\bsp\app\Board_App\camera\QR_Decoder
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: ..\..\Output\Fire_emxgui .sct
software components: Compiler:I/O:STDERR 1.2.0
